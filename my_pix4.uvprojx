# Keil uVision project my_pix4.uvprojx, settings and files
target STM32F427 (ARM-ADS)
  device: STM32F427VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_pix4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\SRC\lib\CMSIS\Include;.\SRC\lib\STM32F4xx_HAL_Driver\Inc;.\SRC\lib\STM32F4xx_HAL_Driver\Src;.\SRC\led;.\SRC\main;.\SRC\uart;.\SRC\timer;.\SRC\spi;.\SRC\i2c
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./SRC/main/: main.c stm32f4xx_it.c
    ./SRC/led/: led.c
    ./SRC/uart/: uart.c
    ./SRC/timer/: timer.c
    ./SRC/spi/: spi.c MPU6000.c lsm303d.c l3gd20h.c ms5611.c
    ./SRC/i2c/: i2c.c rgbled.c
  group LIB
    ./SRC/lib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c
software components: Device:Startup 2.1.0
